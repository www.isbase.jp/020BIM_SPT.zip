Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 0bf2b43a-6102-4418-b428-4da8559a771d, VersionGUID: fc75cf05-5f93-40a2-a090-1f2cbcf50801, NumberOfSaves: 8], CoordinateReference [CoordinateBase: 共有座標]
File name: SPTシリーズ.ifc
Time: 2025-10-31T16:34:54+09:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.30.30 (JPN) - IFC 25.4.30.30

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: レベル:レベル 1, レベル 1
LongName: レベル 1; Elevation: 0 mm

# IfcBuildingElementProxy: ISベース_SPT:SPT251, ISベース_SPT:SPT251:6944
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT251; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SPT:SPT301, ISベース_SPT:SPT301:6957
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT301; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SPT:SPT302, ISベース_SPT:SPT302:6958
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT302; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SPT:SPT303, ISベース_SPT:SPT303:7178
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT303; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SPT:SPT351, ISベース_SPT:SPT351:6966
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT351; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SPT:SPT352, ISベース_SPT:SPT352:6967
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT352; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SPT:SPT401, ISベース_SPT:SPT401:6975
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT401; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SPT:SPT451, ISベース_SPT:SPT451:6984
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT451; sets with these values: 2
